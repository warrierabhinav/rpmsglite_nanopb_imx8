<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NanoPbRpmsglite.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>hello_world</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>hello_world</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>hello_world</project>
                <configuration>ddr_debug</configuration>
            </member>
            <member>
                <project>hello_world</project>
                <configuration>ddr_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>hello_world</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>ddr_debug</name>
            <member>
                <project>hello_world</project>
                <configuration>ddr_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>ddr_release</name>
            <member>
                <project>hello_world</project>
                <configuration>ddr_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
