# IAR project NanoPbRpmsglite.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMX8MQ6DVAJZ; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MIMX8MQ6/drivers; ../../../../../devices/MIMX8MQ6; ../../../../../devices/MIMX8MQ6/utilities/io; ../../../../../devices/MIMX8MQ6/utilities/str; ../../../../../devices/MIMX8MQ6/utilities/log; ../../../../../devices/MIMX8MQ6/utilities; ../rpmsg_lite/lib/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: NanoPbRpmsglite.bin
  ILINK.IlinkOutputFile: Julia_micro8m.out
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../..; ..; ../../../../../devices/MIMX8MQ6/drivers; ../../../../../devices/MIMX8MQ6; ../../../../../devices/MIMX8MQ6/utilities/io; ../../../../../devices/MIMX8MQ6/utilities/str; ../../../../../devices/MIMX8MQ6/utilities/log; ../../../../../devices/MIMX8MQ6/utilities
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: Julia_micro8m.bin
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8MQ6DVAJZ
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../..; ..; ../../../../../devices/MIMX8MQ6/drivers; ../../../../../devices/MIMX8MQ6; ../../../../../devices/MIMX8MQ6/utilities/io; ../../../../../devices/MIMX8MQ6/utilities/str; ../../../../../devices/MIMX8MQ6/utilities/log; ../../../../../devices/MIMX8MQ6/utilities; ../rpmsg_lite/lib/include/platform/imx8mq_m4; ../rpmsg_lite/lib/include
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: Julia_micro8m.bin
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h fsl_iomuxc.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8MQ6/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_i2c.c fsl_i2c.h fsl_mu.c fsl_mu.h fsl_pwm.c fsl_pwm.h fsl_rdc.c fsl_rdc.h fsl_uart.c fsl_uart.h
  group Interface
    ../Interfaces/: mcu.pb.c mcu.pb.h targetdevice.c targetdevice.h
  group NymbleLibrary/NanoPb
    ../NymbleLibrary/NanoPb/: pb.h pb_common.c pb_common.h pb_decode.c pb_decode.h pb_encode.c pb_encode.h
  group NymbleLibrary/RpmsgNymble
    ../NymbleLibrary/RpmsgNymble/: rpmsgnymble.c rpmsgnymble.h
  group rpmsg_lite
    ../rpmsg_lite/lib/common/: llist.c
    ../rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../: rpmsg_config.h
    ../rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/env/baremetal
    ../rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_bm.c
    ../rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group rpmsg_lite/porting
    ../rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mq_m4/: rpmsg_platform.c
    ../rpmsg_lite/lib/include/platform/imx8mq_m4/: rpmsg_platform.h
  group source
    ../: main.c
  group startup
    ../../../../../devices/MIMX8MQ6/iar/: startup_MIMX8MQ6_cm4.s
    ../../../../../devices/MIMX8MQ6/: system_MIMX8MQ6_cm4.c system_MIMX8MQ6_cm4.h
  group utilities
    ../../../../../devices/MIMX8MQ6/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8MQ6/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMX8MQ6/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMX8MQ6/utilities/str/: fsl_str.c fsl_str.h
